;;;
;;;	Tang Nano Console Driver
;;;

;;; mnemonics for I/O
KSF	MACRO
	DC 006031
	ENDM
KCC	MACRO
	DC 006032
	ENDM
KRB	MACRO
	DC 006036
	ENDM
TFL	MACRO
	DC 006040
	ENDM
TSF	MACRO
	DC 006041
	ENDM
TLS	MACRO
	DC 006046
	ENDM
	
INIT:	DC	0
	KCC
	TFL
	CLA
	JMP	I INIT

CONIN:	DC	0
CIN0:
	KSF
	JMP    	CIN0
	KRB
	AND	MASK7
 	DCA	CH
	JMP	I CONIN

CONST:	DC	0
  	CLA
 	IAC
 	KSF
	CLA
 	DCA	CH
	JMP	I CONST

CONOUT:	DC	0
COUT0:
 	TSF
 	JMP 	COUT0
 	CLA
	TAD	CH
	TLS
	CLA
	JMP	I CONOUT

MASK7:	DC	0177
	
